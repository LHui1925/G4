# Keil uVision project Fire_RT-Thread.uvprojx, settings and files
target Fire_RT-Thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_RT-Thread +hex
  c flags: Optim=2 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\rtthread\3.0.3\components\finsh;..\..\rtthread\3.0.3\include;..\..\rtthread\3.0.3\include\libc;..\..\User\Bsp\led;..\..\User\Bsp\key;..\..\User\Bsp\uart;..\..\User\Bsp\HARDWARE\AS608;..\..\User\Bsp\HARDWARE\BEEP;..\..\User\Bsp\HARDWARE\TIMER;..\..\User\Bsp\HARDWARE\USART2;..\..\User\Bsp\HARDWARE\sys;..\..\User\Bsp\HARDWARE\delay;..\..\User\Bsp\Keyboard;..\..\User\Bsp\Handle_AS608;..\..\User\Bsp\Handle_code;..\..\User\Bsp\flash;..\..\User\Bsp\FATFS\option;..\..\User\Bsp\FATFS;..\..\User\Bsp\Handle_flash;..\..\User\Bsp\G4;..\..\User\Bsp\CRC;..\..\User\Bsp\web;..\..\User\Bsp\cJSON;..\..\User\Bsp\BASE64;..\..\User\Bsp\handle;..\..\User\Bsp\SM4;..\..\User\Bsp\HASH;..\..\User\Bsp\lock;..\..\User\Bsp\AS60;..\..\User\Bsp\PLAY;..\..\User\Bsp\CRC;..\..\User\Bsp\STM32_Cryptographic_Library\inc;..\..\User\Bsp\AES
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: board.c rtconfig.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/Bsp/led/: bsp_led.c
    ../../User/Bsp/uart/: bsp_usart.c
    ../../User/Bsp/key/: bsp_key.c
    ../../User/Bsp/HARDWARE/AS608/: as608.c
    ../../User/Bsp/HARDWARE/BEEP/: beep.c
    ../../User/Bsp/HARDWARE/TIMER/: timer.c
    ../../User/Bsp/HARDWARE/USART2/: usart2.c
    ../../User/Bsp/HARDWARE/sys/: sys.c
    ../../User/Bsp/HARDWARE/delay/: delay.c
    ../../User/Bsp/Keyboard/: Key.c
    ../../User/Bsp/Handle_AS608/: Handle_AS608.c
    ../../User/Bsp/Handle_code/: Handle_code.c
    ../../User/Bsp/flash/: bsp_spi_flash.c
    ../../User/Bsp/Handle_flash/: Handle_flash.c
  group DOC
    ../../Doc/: readme.txt
  group rtt/source
    ../../rtthread/3.0.3/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rtt/ports
    ../../rtthread/3.0.3/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group FatFs
    ../../User/Bsp/FATFS/: diskio.c ff.c
    ../../User/Bsp/FATFS/option/: cc936.c
  group INTERNET
    ../../User/Bsp/G4/: G4.c
    ../../User/Bsp/web/: web.c
    ../../User/Bsp/handle/: handle.c
    ../../User/Bsp/SM4/: SM4.c
    ../../User/Bsp/cJSON/: cJSON.c
    ../../User/Bsp/HASH/: MD5.c
    ../../User/Bsp/AS60/: as60test.c as60.c
    ../../User/Bsp/lock/: lock.c
    ../../User/Bsp/PLAY/: play.c
    ../../User/Bsp/AES/: AES.c myaes.c
    ../../User/Bsp/BASE64/: base64.c
    ../../User/Bsp/CRC/: CRC.c
